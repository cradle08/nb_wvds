# IAR project boot.ewp, settings and files
configuration Debug (MSP430, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\lib\dlib\dl430xllfn.h
  General.OGChipSelectMenu: MSP430F5438A MSP430F5438A
  General.GStackSize2: 320
  General.GHeapSize2: 160
  General.RadioHeapSizeType: 0
  ICC430.CCDiagSuppress: Pa050,Pe550
  ICC430.newCCIncludePaths: ..; ..\m25pe
  ICC430.CCOptLevel: 1
  ICC430.CCOptStrategy: 0
  ICC430.IccLang: 0
  XLINK.XclFile: config\linker\lnk430f5438a.xcl
  XLINK.XlinkStackSize: 1
configuration Release (MSP430, debug)
  as the first configuration, except:
  postbuild: Release\postbuild.bat
  group (top)
    ../: crc16.c crc16.h hal-pmm.c hal-pmm.h main.c msp430.c platform.h
  group m25pe
    ../m25pe/: c2195.c c2195.h m25pe-arch.c m25pe-arch.h m25pe.c m25pe.h Serialize.c Serialize.h
