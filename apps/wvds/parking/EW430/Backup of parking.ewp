# IAR project Backup of parking.ewp, settings and files
configuration Debug (MSP430, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\lib\dlib\dl430xlsfn.h
  General.OGChipSelectMenu: MSP430F5438A MSP430F5438A
  General.GStackSize2: 240
  General.GHeapSize2: 160
  General.RadioHeapSizeType: 0
  ICC430.CCDefines: AUTOSTART_ENABLE; NODEID=2; BOARD_CADRE1120_VD=1; IS_SNIFFER_VERSION=1; WRITE_ALGO_FLASH=0; xNO_RADIO
  ICC430.CCDiagSuppress: Pa050
  ICC430.newCCIncludePaths: ..; ..\..\..\..\contiki\core; ..\..\..\..\platform\mist-exp5438; ..\..\..\..\platform\cadre1120; ..\..\..\..\contiki\cpu\msp430; ..\..\..\..\apps\mist-conf; ..\..\..\..\dev\cc1120; ..\..\..\..\apps\aes; ..\..\..\..\dev\mmc3316; ..\..\..\..\dev\hmc5983; ..\..\..\..\dev\qmc5883; ..\..\..\..\apps\at-cmd; ..\..\..\..\apps\wvds\device; ..\..\..\..\apps\wvds
  ICC430.CCOptLevel: 1
  ICC430.CCOptStrategy: 0
  ICC430.IccLang: 0
  XLINK.XclFile: $TOOLKIT_DIR$\config\linker\lnk430f5438a.xcl
  XLINK.XlinkStackSize: 1
configuration Release (MSP430, debug)
  as the first configuration, except:
  postbuild: Release\postbuild.bat
  group apps/aes
    ../../../aes/: aes-ccm.c aes.c netstack-aes.c
  group apps/at-cmd
    ../../../at-cmd/: at-cmd.c at-cmd.h
  group apps/wvds/device
    ../../device/: VehicleDetection.c VehicleDetection.h
  group contiki/core/dev
    ../../../../contiki/core/dev/: leds.c serial-line.c
  group contiki/core/lib
    ../../../../contiki/core/lib/: list.c memb.c random.c ringbuf.c sensors.c
  group contiki/core/net
    ../../../../contiki/core/net/: netstack.c packetbuf.c queuebuf.c
  group contiki/core/net/mac
    ../../../../contiki/core/net/mac/: csma.c frame802154.c framer-802154.c mac.c nullrdc.c
  group contiki/core/net/rime
    ../../../../contiki/core/net/rime/: abc.c announcement.c broadcast-announcement.c broadcast.c chameleon-bitopt.c chameleon.c channel.c rime.c rimeaddr.c rimestats.c
  group contiki/core/sys
    ../../../../contiki/core/sys/: autostart.c ctimer.c energest.c etimer.c process.c rtimer.c taskmon.c timer.c unixtime.c
  group dev/cc1120
    ../../../../dev/cc1120/: cc1120-msp-arch.c cc11xx.c
  group dev/hmc5983
    ../../../../dev/hmc5983/: hmc5983.c hmc5983.h
  group dev/mmc3316
    ../../../../dev/mmc3316/: mmc3316.c mmc3316.h
  group dev/qmc5883
    ../../../../dev/qmc5883/: qmc5883.c qmc5883.h
  group examples/tests/parking
    ../: test.c
  group platform/cadre1120/dev
    ../../../../platform/cadre1120/dev/: battery-sensor.c solarbat-sensor.c solarbat-sensor.h uart.c uart.h
  group platform/mist-exp5438
    ../../../../platform/mist-exp5438/: clock.c contiki-exp5438-main.c duty-cycle-scroller.c flash.c hal-pmm.c hal_lcd.c hal_lcd_fonts.c lcd.c leds-arch.c msp430.c node-id.c rtimer-arch.c slip_uart1.c spix.c stack-avail.c uart1-putchar.c uart1x.c uart3-putchar.c uart3x.c watchdog.c
