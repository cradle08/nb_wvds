# IAR project nb_wvds.ewp, settings and files
configuration Debug (MSP430, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\lib\dlib\dl430xlsfn.h
  General.OGChipSelectMenu: MSP430F5310 MSP430F5310
  General.GStackSize2: 80
  General.GHeapSize2: 80
  General.RadioHeapSizeType: 0
  ICC430.newCCIncludePaths: $PROJ_DIR$; apps; apps\aes; apps\at-cmd; apps\nb_wvds; contiki\apps; contiki\core; contiki\core\dev; contiki\core\lib; contiki\core\net; contiki\core\sys; dev\; dev\bc95; dev\m25pe; dev\qmc5883; platform; platform\f5310
  ICC430.CCOptLevel: 1
  ICC430.CCOptStrategy: 0
  ICC430.IccLang: 0
  XLINK.XclFile: lnk0t.xcl
  XLINK.XlinkStackSize: 1
configuration Release (MSP430)
  as the first configuration, except:
  General.RTConfigPath: xxx.h
  ICC430.CCDefines: NDEBUG
  ICC430.CCOptLevel: 3
  ICC430.ADefines: NDEBUG
  group apps/aes
    ../../aes/: aes-ccm.c aes-ccm.h aes.c aes.h netstack-aes.c netstack-aes.h
  group apps/at-cmd
    ../../at-cmd/: at-cmd.c at-cmd.h
  group apps/nb_wvds
    ../../nb_wvds/: app.c app.h cfs-flash.c cfs-flash.h device.c project-conf.h VehicleDetection.c VehicleDetection.h
  group contiki/core
    ../../../contiki/core/: contiki.h
  group contiki/core/dev
    ../../../contiki/core/dev/: leds.c leds.h serial-line.c serial-line.h
  group contiki/core/lib
    ../../../contiki/core/lib/: assert.c assert.h crc16.c crc16.h list.c list.h memb.c memb.h random.c random.h ringbuf.c ringbuf.h sensors.c sensors.h
  group contiki/core/sys
    ../../../contiki/core/sys/: autostart.c autostart.h clock.h compower.c compower.h ctimer.c ctimer.h energest.c energest.h etimer.c etimer.h logger.c logger.h process.c process.h rtimer.c rtimer.h taskmon.c taskmon.h timer.c timer.h unixtime.c unixtime.h
  group dev/bc95
    ../../../dev/bc95/: bc95.c bc95.h uart.c uart.h
  group dev/m25pe
    ../../../dev/m25pe/: c2195.c c2195.h m25pe.c m25pe.h Serialize.c Serialize.h
  group dev/qmc5883
    ../../../dev/qmc5883/: qmc5883.c qmc5883.h
  group platform/f5310
    ../../../platform/f5310/: blink.c clock.c contiki-conf.h contiki-f5310-main.c flash.c hal-pmm.c hal-pmm.h leds-arch.c msp430.c msp430def.h rtimer-arch.c spix.c uart1-putchar.c uart1x.c uart3-putchar.c uart3x.c watchdog.c
