# IAR project nb_wvds.ewp, settings and files
configuration Debug (MSP430, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\lib\dlib\dl430xlsfn.h
  General.OGChipSelectMenu: MSP430F5310 MSP430F5310
  General.GStackSize2: 160
  General.GHeapSize2: 160
  General.RadioHeapSizeType: 0
  ICC430.newCCIncludePaths: nb_device; ; ..\aes; ..\at-cmd; ..\..\contiki\; ..\..\contiki\core\; ..\..\dev; ..\..\dev\bc95; ..\..\dev\m25pe; ..\..\dev\qmc5883; ..\..\platform\f5310\
  ICC430.CCOptLevel: 1
  ICC430.CCOptStrategy: 0
  ICC430.IccLang: 0
  XLINK.XclFile: $TOOLKIT_DIR$\config\linker\lnk430f5310.xcl
  XLINK.XlinkStackSize: 1
configuration Release (MSP430)
  as the first configuration, except:
  General.GStackSize2: 80
  General.GHeapSize2: 80
  ICC430.CCDefines: NDEBUG
  ICC430.CCOptLevel: 3
  ICC430.ADefines: NDEBUG
  XLINK.XclFile: lnk0t.xcl
  group apps/nb_wvds/nb_device
    nb_device/: app.c app.h nb_code.c nb_code.h project-conf.h VehicleDetection.c VehicleDetection.h
  group contiki/core
    ../../contiki/core/: contiki.h
  group contiki/core/dev
    ../../../contiki/core/dev/: watchdog.h
  group contiki/core/lib
    ../../contiki/core/lib/: assert.c assert.h crc16.c crc16.h list.c list.h memb.c memb.h random.c random.h ringbuf.c ringbuf.h
  group contiki/core/sys
    ../../contiki/core/sys/: autostart.c autostart.h cc.h clock.h compower.c compower.h ctimer.c ctimer.h etimer.c etimer.h logger.c logger.h process.c process.h procinit.c procinit.h stimer.c stimer.h timer.c timer.h unixtime.c unixtime.h
  group dev/bc95
    ../../dev/bc95/: bc95.c bc95.h
  group dev/qmc5883
    ../../dev/qmc5883/: qmc5883.c qmc5883.h
  group platform/f5310
    ../../platform/f5310/: clock.c contiki-f5310-main.c hal_lcd.h isr_compat.h msp430.c msp430.h platform-conf.h rtc.c rtc.h uart1.c uart1.h watchdog.c watchdog.h
