<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\..\..\nb_test\nb_test.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\nb_wvds.ewp</path>
    </project>
    <batchBuild />
</workspace>
