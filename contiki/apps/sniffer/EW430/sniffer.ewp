# IAR project sniffer.ewp, settings and files
configuration Debug (MSP430, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\lib\dlib\dl430xllfn.h
  General.OGChipSelectMenu: MSP430F5438A MSP430F5438A
  General.GStackSize2: 256
  General.GHeapSize2: 160
  General.RadioHeapSizeType: 0
  ICC430.CCDefines: NODEID=65533; WITH_MCU_LPM=0; BOARD_CADRE1120_VD=1; AUTOSTART_ENABLE; CONTIKI_TARGET_CADRE1120; RADIO_CC11xx; PROJECT_CONF_H="project-conf.h"
  ICC430.CCDiagSuppress: Pa050,Pe550
  ICC430.newCCIncludePaths: ..; ..\..\..\contiki\core; ..\..\..\platform\mist-exp5438; ..\..\..\platform\cadre1120; ..\..\..\contiki\cpu\msp430; ..\..\..\apps\mist-conf; ..\..\..\dev\cc1120; ..\..\..\apps\aes; ..\..\..\dev\mmc3316
  ICC430.CCOptLevel: 1
  ICC430.CCOptStrategy: 0
  ICC430.IccLang: 0
  XLINK.XclFile: $TOOLKIT_DIR$\config\linker\lnk430f5438a.xcl
  XLINK.XlinkStackSize: 1
configuration Release (MSP430, debug)
  as the first configuration, except:
  prebuild: prebuild.bat
  postbuild: Release\postbuild.bat
  group apps/aes
    ../../aes/: aes-ccm.c aes.c netstack-aes.c
  group apps/sniffer
    ../: hdlc.c hdlc.h project-conf.h sniffer.c stub-nwk.c stub-rdc.c
  group contiki/core/dev
    ../../../contiki/core/dev/: leds.c serial-line.c
  group contiki/core/lib
    ../../../contiki/core/lib/: list.c memb.c random.c ringbuf.c sensors.c
  group contiki/core/net
    ../../../contiki/core/net/: netstack.c packetbuf.c queuebuf.c
  group contiki/core/net/mac
    ../../../contiki/core/net/mac/: csma.c frame802154.c framer-802154.c mac.c nullmac.c nullrdc.c
  group contiki/core/net/rime
    ../../../contiki/core/net/rime/: abc.c announcement.c broadcast-announcement.c broadcast.c chameleon-bitopt.c chameleon.c channel.c rime.c rimeaddr.c rimestats.c unicast.c
  group contiki/core/sys
    ../../../contiki/core/sys/: autostart.c ctimer.c energest.c etimer.c process.c rtimer.c taskmon.c timer.c unixtime.c
  group dev/cc1120
    ../../../dev/cc1120/: cc1120-msp-arch.c cc11xx.c
  group dev/mmc3316
    ../../../dev/mmc3316/: mmc3316.c
  group platform/cadre1120/dev
    ../../../platform/cadre1120/dev/: battery-sensor.c solarbat-sensor.c solarbat-sensor.h uart.c uart.h
  group platform/mist-exp5438
    ../../../platform/mist-exp5438/: clock.c contiki-conf.h contiki-exp5438-main.c duty-cycle-scroller.c flash.c hal-pmm.c hal_lcd.c hal_lcd_fonts.c lcd.c leds-arch.c msp430.c node-id.c rs232.c rtimer-arch.c slip_uart1.c spix.c stack-avail.c uart1-putchar.c uart1x.c uart3-putchar.c uart3x.c watchdog.c
